<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Time9_10.ewp</path>
  </project>
  <batchBuild />
</workspace>
