<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\UART_INT_LED_FND.ewp</path>
  </project>
  <batchBuild />
</workspace>
