<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TIME3_FND.ewp</path>
  </project>
  <batchBuild />
</workspace>
